# Keil uVision project lpc2468-lwip.uvproj, settings and files
target Flash (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC2468-OS-TCPIP +hex
  AfterMake: fromelf .\OutPut\LPC2468-OS-TCPIP.axf --output .\OutPut\LPC2468-OS-TCPIP.elf
  c flags: Optim=1
  c include: .;..\..\app;..\BSP;..\..\uCOS-II\Ports;..\..\uCOS-II\Source;..\..\uC-CPU;..\..\uC-LIB;..\..\lwip\src\include;..\..\lwip\src;..\..\lwip\src\arch\include;..\..\lwip\src\include\ipv4;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x3800
  group APP
    ./: app.c app_cfg.h includes.h net_cfg.h os_cfg.h
    ../../App/: smartarm2300.h applib.h TimerExt.c Blinky.c
  group BSP
    ./: bsp.c bsp_i2c.c net_bsp.h bsp.h iolpc23xx.h LPC2400.s emac.c nic_bsp.c dm9161.c
  group uC-CPU
    ../../uC-CPU/: cpu_def.h cpu.h cpu_a.s
  group uC-OS-II/Source
    ../../uCOS-II/Source/: os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_core.c
  group uC-OS-II/Port
    ../../uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC-LIB
    ../../uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group Scatter
    ./: LPC2468_RAM.ini LPC2468_Flash.scat
  group LwIP
    ../../lwip/src/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
    ../../lwip/src/arch/: sys_arch_init.c sys_arch.c
    ../../lwip/src/core/: udp.c dhcp.c dns.c init.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c sys.c mem.c memp.c
    ../../lwip/src/core/ipv4/: ip_frag.c autoip.c icmp.c inet.c inet_chksum.c ip.c ip_addr.c
    ../../lwip/src/netif/: etharp.c ethernetif.c loopif.c
target Flash-J (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: as above
  output: LPC2468-OS-TCPIP +hex
  AfterMake: as above
  c flags: Optim=1
  c include: .;..\..\app;..\BSP;..\..\uCOS-II\Ports;..\..\uCOS-II\Source;..\..\uC-CPU;..\..\uC-LIB;..\..\uC-TCPIP\OS\uCOS-II;..\..\lwip\src\include;..\..\lwip\src;..\..\lwip\src\arch\include;..\..\lwip\src\include\ipv4;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x3800
