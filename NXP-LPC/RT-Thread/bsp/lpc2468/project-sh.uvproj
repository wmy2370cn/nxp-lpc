# Keil uVision project project-sh.uvproj, settings and files
target RT-Thread/LPC2468 (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: rtthread-lpc2468 +hex
  c flags: Optim=1
  c include: .;..\..\include;..\..\libcpu\arm\lpc24xx;..\..\finsh;..\..\net\lwip\src;..\..\net\lwip\src\include;..\..\net\lwip\src\arch\include;..\..\net\lwip\src\include\ipv4;..\..\app;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --keep __fsym_* --keep __vsym_*
  group Startup
    ./: application.c board.c startup.c rtconfig.h nic_bsp.c
  group Kernel
    ../../src/: clock.c device.c ipc.c mempool.c object.c timer.c idle.c irq.c mem.c scheduler.c slab.c kservice.c thread.c
  group LPC2468
    ../../libcpu/arm/lpc24xx/: cpu.c interrupt.c serial.c stack.c trap.c context_rvds.s start_rvds.s
  group finsh
    ../../finsh/: finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c cmd.c finsh_parser.c
  group LwIP
    ../../net/lwip/src/netif/: etharp.c ethernetif.c
    ../../net/lwip/src/core/: udp.c dhcp.c dns.c init.c memp_tiny.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c
    ../../net/lwip/src/core/ipv4/: ip_frag.c autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c
    ../../net/lwip/src/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
    ../../net/lwip/src/arch/: sys_arch_init.c sys_arch.c
  group app
    ../../app/: main.c
