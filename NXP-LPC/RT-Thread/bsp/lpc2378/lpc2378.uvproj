# Keil uVision project lpc2378.uvproj, settings and files
target RT-Thread/LPC2378 (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: lpc2468
  c flags: Optim=1
  c include: .;..\..\include;..\..\libcpu\arm\lpc24xx;..\..\net\lwip\src\include;..\..\net\lwip\src;..\..\net\lwip\src\arch\include;..\..\net\lwip\src\include\ipv4;..\..\app;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup
    ./: startup.c application.c board.c nic_bsp.c rtconfig.h
  group Kernel
    ../../src/: timer.c clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c slab.c thread.c
  group lpc2468
    ../../libcpu/arm/lpc24xx/: trap.c cpu.c interrupt.c serial.c stack.c context_rvds.s start_rvds.s
  group app
    ../../app/: main.c
  group LwIP
    ../../net/lwip/src/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
    ../../net/lwip/src/arch/: sys_arch_init.c sys.c sys_arch.c
    ../../net/lwip/src/core/: udp.c dhcp.c dns.c init.c memp_tiny.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c
    ../../net/lwip/src/core/ipv4/: ip_frag.c autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c
    ../../net/lwip/src/netif/: etharp.c ethernetif.c loopif.c
    ../../net/lwip/src/core/snmp/: msg_out.c asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c
