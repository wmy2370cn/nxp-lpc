# Keil uVision project lpc2378-lwip.uvproj, settings and files
target Flash (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC2378-OS-TCPIP +hex
  AfterMake: fromelf .\OutPut\LPC2378-OS-TCPIP.axf --output .\OutPut\LPC2378-OS-TCPIP.elf
  c flags: Optim=1
  c include: .;..\BSP;..\..\uCOS-II\Ports;..\..\uCOS-II\Source;..\..\uC-CPU;..\..\uC-LIB;..\..\uC-TCPIP\IF;..\..\uC-TCPIP\IF\Ether;..\..\uC-TCPIP\NIC\ETHER\LPC2378;..\..\uC-TCPIP\NIC\ETHER\PHY;..\..\uC-TCPIP\NIC\ETHER\PHY\DM9161AE;..\..\uC-TCPIP\OS\uCOS-II;..\..\uC-TCPIP\Source;..\..\..\..\..\uCOSView\Source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x3800
  group APP
    ./: app.c app_cfg.h includes.h net_cfg.h os_cfg.h
  group BSP
    ./: bsp.c bsp_i2c.c net_isr.c net_bsp.c net_bsp.h bsp.h iolpc23xx.h LPC2300.s
  group uC-CPU
    ../../uC-CPU/: cpu_def.h cpu.h cpu_a.s
  group uC-OS-II/Source
    ../../uCOS-II/Source/: os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_core.c
  group uC-OS-II/Port
    ../../uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC-LIB
    ../../uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group Scatter
    ./: LPC2378_RAM.ini LPC2378_Flash.scat
