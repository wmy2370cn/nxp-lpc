# Keil uVision project LPC2468-TCPIP.uvproj, settings and files
target Flash (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC2468-OS-TCPIP +hex
  AfterMake: fromelf .\OutPut\LPC2468-OS-TCPIP.axf --output .\OutPut\LPC2468-OS-TCPIP.elf
  c flags: Optim=1
  c include: .;..\BSP;..\..\uCOS-II\Ports;..\..\uCOS-II\Source;..\..\uC-CPU;..\..\uC-LIB;..\..\uC-TCPIP\IF;..\..\uC-TCPIP\IF\Ether;..\..\uC-TCPIP\NIC\ETHER\LPC2468;..\..\uC-TCPIP\NIC\ETHER\PHY;..\..\uC-TCPIP\NIC\ETHER\PHY\DM9161AE;..\..\uC-TCPIP\OS\uCOS-II;..\..\uC-TCPIP\Source;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group APP
    ./: app.c app_cfg.h includes.h net_cfg.h os_cfg.h
  group BSP
    ./: bsp.c bsp_i2c.c net_isr.c net_bsp.c net_bsp.h bsp.h LPC2400.s
  group uC-CPU
    ../../uC-CPU/: cpu_def.h cpu.h cpu_a.s
  group uC-OS-II/Source
    ../../uCOS-II/Source/: os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_core.c
  group uC-OS-II/Port
    ../../uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC-LIB
    ../../uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group uC-TCPIP/IF
    ../../uC-TCPIP/IF/: net_if_pkt.c net_if_pkt.h
  group uC-TCPIP/IF/Ether
    ../../uC-TCPIP/IF/Ether/: net_if.h net_if.c
  group uC-TCPIP/NIC/ETHER/LPC2468
    ../../uC-TCPIP/NIC/ETHER/LPC2468/: net_nic_def.h net_nic.h net_nic.c
  group uC-TCPIP/NIC/ETHER/PHY
    ../../uC-TCPIP/NIC/ETHER/PHY/: net_phy_def.h
  group uC-TCPIP/NIC/ETHER/PHY/DM9161AEP
    ../../uC-TCPIP/NIC/ETHER/PHY/DM9161AE/: net_phy.c net_phy.h
  group uC-TCPIP/OS/uCOS-II
    ../../uC-TCPIP/OS/uCOS-II/: net_os.h net_os.c
  group uC-TCPIP/Port
    ../../uC-TCPIP/Ports/: net_util_a.asm
  group uC-TCPIP/Source
    ../../uC-TCPIP/Source/: net_sock.h net_stat.c net_stat.h net_tcp.c net_tcp.h net_tmr.c net_tmr.h net_type.h net_udp.c net_udp.h net_util.c net_util.h net.c net.h net_arp.c net_arp.h net_ascii.c net_ascii.h net_bsd.c net_bsd.h net_buf.c net_buf.h net_cfg_net.h net_conn.c net_conn.h net_ctr.c net_ctr.h net_dbg.c net_dbg.h net_def.h net_err.c net_err.h net_icmp.c net_icmp.h net_ip.c net_ip.h net_sock.c
  group Scatter
    ./: LPC2468_Flash.scat LPC2468_RAM.scat LPC2468_RAM.ini
target Flash-U (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: as above
  output: LPC2468-OS-TCPIP +hex
  AfterMake: as above
  c flags: Optim=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
target Flash-J (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: as above
  output: LPC2468-OS-TCPIP +hex
  AfterMake: as above
  c flags: Optim=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
