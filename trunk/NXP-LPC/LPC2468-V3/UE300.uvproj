# Keil uVision project UE300.uvproj, settings and files
target V3 (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: UE300 +hex
  AfterMake: fromelf .\OutPut\UE300.axf --output .\OutPut\UE300.elf
  AfterMake: find "Total R" .\OutPut\UE300.map
  c flags: Optim=1
  c include: .\uCOSII;.\USER;.\Hardware;.\Common;.\MBX;.\Main;.\GUI;..\;.\LwIP\include;.\LwIP\include\ipv4;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x7fd00000 size 0x4000
  memory RVCT7: RAM 0x7fe00000 size 0x4000
  memory RVCT9: RAM 0x40000000 size 0x10000
  group uCOSII
    ./uCOSII/: OS_CORE.c OS_DBG_R.c OS_FLAG.c OS_MBOX.c OS_MEM.c OS_MUTEX.c OS_Q.c OS_SEM.c OS_TASK.c OS_TIME.c OS_TMR.c
  group USER
    ./USER/: BSP.c Main.c OS_CPU_C.c OS_CPU_A.s OS_INT_A.s LPC2400.s vicControl.s
  group Main
    ./Main/: IoAdapter.c MainTask.c MemData.c AdvCalc.c FileData.c DataRecorder.c FlashApiWrapper.c IoScan.c Ram.c FRamMgr.c UEInit.c
  group Hardware
    ./Hardware/: hd_drive.c hd_Init.c IAP.c uart.c LcdDriver.c I2cHook.c I2c.c hd_ISR.c emac.c
  group Common
    ./Common/: Queue.c Func.c ClockMgr.c TimerMgr.c
  group MBX
    ./MBX/: MBFunc.c MBCommon.c MBSlave.c
  group GUI
    ./GUI/: WordStock.c asc8_8.c ascil_8_16.c CtrlBase.c DC.c DeviceCfgScreen.c global.c Gui.c Icon.c Key.c LogoScreen.c Message.c MsgBox.c ScreenBase.c ScreenEdit.c StringTable.c
  group LwIP
    ./LwIP/: LwIPEntry.c
  group LwIP_netif
    ./LwIP/netif/: etharp.c ethernetif.c loopif.c slipif.c
  group LwIP_core
    ./LwIP/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./LwIP/core/: udp.c dhcp.c dns.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c init.c
  group LwIP_api
    ./LwIP/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP_arch
    ./LwIP/arch/: sys_arch.c
