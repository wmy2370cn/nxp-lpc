# Keil uVision project V0.uvproj, settings and files
target V0 (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: UE +hex
  AfterMake: fromelf .\OutPut\UE.axf --output .\OutPut\UE.elf
  AfterMake: find "Total R" .\OutPut\UE.map
  c flags: Optim=1
  c include: .\uCOSII;.\USER;.\Hardware;.\Common;.\MBX;.\Main;.\GUI;..\;.\LwIP\include;.\LwIP\include\ipv4;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x7fd00000 size 0x4000
  memory RVCT7: RAM 0x7fe00000 size 0x4000
  memory RVCT9: RAM 0x40000000 size 0x10000
  group uCOSII
    ./uCOSII/: OS_CORE.c OS_DBG_R.c OS_FLAG.c OS_MBOX.c OS_MEM.c OS_MUTEX.c OS_Q.c OS_SEM.c OS_TASK.c OS_TIME.c OS_TMR.c
  group USER
    ./USER/: BSP.c Main.c OS_CPU_C.c OS_CPU_A.s OS_INT_A.s LPC2400.s vicControl.s
  group Main
    ./Main/: IoAdapter.c MainTask.c MemData.c Ram.c
  group Hardware
    ./Hardware/: hd_drive.c hd_Init.c IAP.c uart.c LcdDriver.c I2cHook.c I2c.c
  group Common
    ./Common/: Queue.c Func.c ClockMgr.c TimerMgr.c
